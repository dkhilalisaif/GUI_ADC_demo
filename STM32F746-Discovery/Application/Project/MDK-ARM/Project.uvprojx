# Keil uVision project Project.uvprojx, settings and files
target STM32F746-Discovery (6140000::V6.14::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: EmbeddedWizard-STM32F746-Discovery +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=4 wLevel=3
  c define: USE_HAL_DRIVER STM32F746xx USE_STM32746G_DISCO EW_USE_FREE_RTOS=1 EW_USE_EXTERNAL_FLASH=1 EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource
  c include: ../Inc;..\..\..\ThirdParty\STM32Cube_FW_F7/Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\..\..\ThirdParty\STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Inc;..\..\..\ThirdParty\STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery;..\..\..\ThirdParty\STM32Cube_FW_F7/Drivers/BSP/Components;..\..\..\ThirdParty\STM32Cube_FW_F7\Drivers/CMSIS/Include;..\..\..\TargetSpecific;..\..\..\TargetSpecific\Drivers;..\..\GeneratedCode;..\..\Source;..\..\..\ThirdParty\STM32Cube_FW_F7\MiddleWares\Third_Party\FreeRTOS\Source\include;..\..\..\ThirdParty\STM32Cube_FW_F7\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\ThirdParty\STM32Cube_FW_F7\MiddleWares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x1000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32746G-DISCOVERY.sct
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32746G-DISCOVERY
    ../../../ThirdParty/STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sdram.c stm32746g_discovery.c stm32746g_discovery_qspi.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_graphics.c ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_system.c ew_bsp_touch.c stm32f7xx_it.c system_stm32f7xx.c
    ../../../TargetSpecific/Drivers/: ft5336.c
  group EmWi/Application
    ./: startup_stm32f746xx.s
    ../../Source/: main.c DeviceDriver.c ewmain.c ewconfig.h
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c list.c
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
